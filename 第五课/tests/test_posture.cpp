// ============================================================================
// 文件名：tests/test_posture.cpp
// 它是谁？—— 算法大脑（Posture.h）在电脑上的“自动化模拟考试卷”
//
// 【给中学生的阅读指南】
// 什么是“单元测试（Unit Test）”？
// 在把代码烧录进 ESP32 开发板、绑到腿上之前，我们先在电脑上编好一份“考卷”（就是这个文件），
// 里面故意设计了各种刁钻的假数据（比如破损的数据包、刚好差 12 毫秒和 13 毫秒的两帧、
// 刚好在 ±180° 分界线跳变的角度、混进了一帧 140° 剧烈震动刺点的腰部数据……），
// 一道题一道题地喂给 Posture.h 里的函数，看它算出来的答案跟我们手算的标准答案一不一样！
//
// 【认识 C++ 里的判卷老师：assert(条件)】
// assert 叫“断言”。括号里写的是“必须成立的正确答案”：
//   • 如果括号里的条件为真（true），判卷老师就默不作声放行，继续考下一题；
//   • 只要有任何一道题算错了（条件为 false），程序会立刻当场停下，并在屏幕上报错指出是第几行算错了！
//   • 如果从头到尾几十道题全都闯关成功，最后就会打印出：
//     "PASS: packet, pairing, knee angle, hold, waist window, gap"
// ============================================================================

#include "../SkiCoach3IMU/Posture.h" // 引入我们要考试的“纯数学算法大脑”
#include <cassert>                   // 引入判卷老师 assert()
#include <iostream>                  // 引入电脑屏幕打印工具 std::cout

int main() {
    // ========================================================================
    // 考题一：测试【第 3 关】膝关节弯曲角 kneeFlexion() 与跨 ±180° 边界折返
    // ========================================================================
    // 1. 考讲义上的例题：
    //    站直校准时零偏 standingDiff = 6°；屈膝时大腿 thigh = -8°，小腿 shank = 12°。
    //    标准答案：K = 12 - (-8) - 6 = 14°。
    assert(ski::kneeFlexion(-8, 12, 6) == 14);

    // 2. 考 ±180° 圆盘分界线跳变：
    //    大腿在 +179°，小腿往负方向跨过分界线到了 -179°，零偏为 0°。
    //    如果直接减会算出 -358°（大错特错！），经过 wrap180 折返后，真实只弯了 +2°！
    assert(ski::kneeFlexion(179, -179, 0) == 2);

    // 3. 考站直归零：
    //    站直时大腿 -4°，小腿 +2°，站直零偏就是 6°。此时算出来的膝角必须严格等于 0°！
    assert(ski::kneeFlexion(-4, 2, 6) == 0);

    // ========================================================================
    // 考题二：测试【第 1 关】54 字节无线快递拆包员 decodeFrame()
    // ========================================================================
    // 我们在电脑内存里手工捏造一包 54 字节的假传感器数据 bytes[54]：
    uint8_t bytes[54] = {};
    // 1) 前 12 个字节塞入合法的设备编号 "WT5500014327"
    std::memcpy(bytes, "WT5500014327", 12);

    // 2) 塞入 X 轴角度（第 38、39 字节）：
    //    第 38 字节（低字节）保持为 0，第 39 字节（高字节）设为 0x40（十六进制的 40 就是十进制的 64）。
    //    拼起来 value = 0 + 256 × 64 = 16384。换算成角度：16384 ÷ 32768 × 180° = +90°！
    bytes[39] = 0x40;

    // 3) 塞入 Y 轴角度（第 40、41 字节）：
    //    第 40 字节为 0，第 41 字节设为 0xC0（十进制的 192）。
    //    拼起来 value = 0 + 256 × 192 = 49152（大于 32768，是负数！）。
    //    减去 65536 得到 signedValue = -16384。换算成角度：-16384 ÷ 32768 × 180° = -90°！
    bytes[41] = 0xC0;

    // 4) 最后两个字节（第 52、53 字节）塞入标准结尾：回车 0x0D 和换行 0x0A
    bytes[52] = 0x0D;
    bytes[53] = 0x0A;

    ski::Frame frame;
    // 检查 1：这包标准的 54 字节数据必须能拆包成功（返回 true）
    assert(ski::decodeFrame(bytes, sizeof(bytes), frame));
    // 检查 2：拆出来的设备号必须一字不差地等于 "WT5500014327"
    assert(std::strcmp(frame.id, "WT5500014327") == 0);
    // 检查 3：拆出来的 X 轴角必须是 +90°，Y 轴角必须是 -90°
    assert(frame.angle[0] == 90 && frame.angle[1] == -90);
    // 检查 4（故意使坏）：如果包裹少了 1 个字节（只传 53 字节），安检员必须拒收（返回 false）！
    assert(!ski::decodeFrame(bytes, 53, frame));
    // 检查 5（故意使坏）：把最后一个换行符改成 0 破坏掉，安检员也必须拒收（返回 false）！
    bytes[53] = 0;
    assert(!ski::decodeFrame(bytes, sizeof(bytes), frame));

    // ========================================================================
    // 考题三：测试【第 2 关】大腿与小腿的 12 毫秒配对室 Pairer
    // ========================================================================
    ski::Pairer pair;
    uint32_t delta = 0;
    // 1) 100ms 时：大腿(0)到了（角度 8°）。此时小腿座位没人，必须返回 false 等待。
    assert(!pair.push(0, 100, 8, delta));
    // 2) 113ms 时：小腿(1)到了（角度 10°）。跟 100ms 的大腿一比，差了 13ms > 12ms！
    //    100ms 的旧大腿过期作废被踢走，不能配对（返回 false），但 113ms 的小腿留下来继续等。
    assert(!pair.push(1, 113, 10, delta));
    // 3) 125ms 时：新大腿(0)到了（角度 9°）。跟刚才留下的 113ms 小腿一比，125 - 113 = 12ms <= 12ms！
    //    刚好卡在及格线上！必须配对成功（返回 true），并且算出的时差 delta 必须等于 12！
    assert(pair.push(0, 125, 9, delta) && delta == 12);
    // 4) 126ms 时：新小腿(1)又到了（角度 11°）。因为 125ms 的大腿在上一行已经牵手成功并清空座位了，
    //    绝不能拿 125ms 的大腿重复配对第二次！所以必须返回 false。
    assert(!pair.push(1, 126, 11, delta));

    // 5) 考计时器 49.7 天溢出回绕：
    //    假如大腿在 32位整数快满的最后时刻（UINT32_MAX - 4）到达，小腿在回绕过 0 之后的第 5 毫秒到达，
    //    真实经过的时间是 4 + 1 + 5 = 10 毫秒 <= 12 毫秒，无符号减法依然能准确配对成功！
    pair.reset();
    assert(!pair.push(0, UINT32_MAX - 4, 0, delta));
    assert(pair.push(1, 5, 0, delta) && delta == 10);

    // ========================================================================
    // 考题四：测试【第 5 关】铁面裁判秒表 Hold（以膝角 800 毫秒规则为例）
    // ========================================================================
    ski::Hold low;
    // 1) 100ms 时开始越界（true）：按下秒表记下起点 100ms，此时才过 0ms，不报警（false）
    assert(!low.update(100, true, 800));
    // 2) 899ms 时还在越界（true）：899 - 100 = 799ms，还差 1 毫秒才满 800ms！铁面裁判绝不提前报警（false）
    assert(!low.update(899, true, 800));
    // 3) 900ms 时还在越界（true）：900 - 100 = 800ms，刚好满时！吹哨报警（返回 true）！
    assert(low.update(900, true, 800));
    // 4) 1200ms 时继续越界（true）：虽然已经越界 1100ms 了，但刚才 900ms 已经报过一次警（emitted 锁死），绝不重复刷屏（false）
    assert(!low.update(1200, true, 800));
    // 5) 1210ms 时姿势恢复正常（false）：秒表自动彻底清零！
    assert(!low.update(1210, false, 800));
    // 6) 1220ms 时再次越界（true）：因为刚才清零了，现在必须从 1220ms 重新起表算 0ms，不能立刻报警（false）
    assert(!low.update(1220, true, 800));

    // 手动清零后，再测一轮从 2500ms 到 3300ms（刚好 800ms）正常触发报警：
    low.reset();
    assert(!low.update(2500, true, 800));
    assert(low.update(3300, true, 800));

    // ========================================================================
    // 考题五：测试【第 4 关】腰部 1 秒滑动窗口 WaistWindow 与抗刺点干扰
    // ========================================================================
    ski::WaistWindow window;
    float wave = -1;

    // 1) 考“没攒满 1 秒绝不乱算”和“固定姿势倾斜波动为 0”：
    //    从 0ms 到 980ms，每 20ms 喂一帧固定的倾斜角（前后倾 15°，左右倾 -5°）。
    //    因为还没满 1000ms，push 必须全部返回 false。
    for (uint32_t t = 0; t < 1000; t += 20) {
        assert(!window.push(t, 15, -5, wave));
    }
    // 到了第 1000ms，刚好攒满 1 秒（且有 51 个样本 >= 35）！
    // 因为你一直保持 (15°, -5°) 固定姿势没晃，算出来的波动 wave 必须等于 0°！
    assert(window.push(1000, 15, -5, wave) && wave == 0);

    // 2) 考“体操裁判 P90 - P10 砍掉刺点噪声”：
    //    清空窗口后，我们在 0 ~ 1000ms 内，让左右倾（roll）在 -6° 和 +6° 之间来回摇摆（真实晃动幅度 = 6 - (-6) = 12°）；
    //    同时，我们在 t = 500ms 那一帧，故意在前后倾（pitch）里塞入一个 140° 的剧烈震动假刺点（其余帧全为 0°）！
    window.clear();
    for (uint32_t t = 0; t <= 1000; t += 20) {
        window.push(t, t == 500 ? 140 : 0, (t % 40) ? -6 : 6, wave);
    }
    // 如果用最大值减最小值，会被那个 140° 的刺点骗成 140°；
    // 但我们的 P90 - P10 直接把排在最顶端的 140° 刺点砍掉了，算出来的 wave 依然稳稳等于真实的 12°！
    assert(wave == 12);

    // 3) 考“超过 100ms 断流自动清零”与“跨 ±180° 边界小幅晃动”：
    //    上一帧是 1000ms，现在突然跳到 1200ms（中间断了 200ms > 100ms GapMs），窗口必须自动清空并返回 false！
    assert(!window.push(1200, 0, 0, wave));
    // 从 1300ms 到 2300ms 重新攒满 1 秒，让角度在 -179° 和 +179° 之间跨过分界线来回摆动（真实只晃了 2°）。
    for (uint32_t t = 0; t <= 1000; t += 20) {
        window.push(1300 + t, (t % 40) ? -179 : 179, 0, wave);
    }
    // 窗口内部因为做了 wrap180 相对展开，绝不会误算成 358°，算出来的 wave 必须精准等于 2°！
    assert(wave == 2);

    // ========================================================================
    // 考题六：单独测试腰部事件的 500 毫秒秒表
    // ========================================================================
    ski::Hold sway;
    assert(!sway.update(1500, true, 500)); // 1500ms 开始晃动超标
    assert(!sway.update(1999, true, 500)); // 1999ms 才满 499ms，差 1ms 不报
    assert(sway.update(2000, true, 500));  // 2000ms 满 500ms，精准触发 PELVIS_SWAY 报警！
    assert(!sway.update(2001, true, 500)); // 2001ms 锁死不重复报

    // 所有考题全部通过！在屏幕上打印满分通关贺电！
    std::cout << "PASS: packet, pairing, knee angle, hold, waist window, gap\n";
}
