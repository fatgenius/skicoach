// ============================================================================
// 文件名：Posture.h
// 它是谁？—— 滑雪教练装置的“纯数学大脑”（核心算法层）
//
// 【给中学生的阅读指南】
// 为什么我们要把这个文件从主程序（SkiCoach3IMU.ino）里单独拆出来？
// 想象一下：如果把整个装置比作一个机器人——
//   • SkiCoach3IMU.ino 是机器人的“耳朵和嘴巴”（负责连 Wi-Fi、收数据包、往电脑串口打字）。
//   • Posture.h 就是机器人的“纯数学大脑”（只负责算角度、配对、计时、判断动作标不标准）。
//
// 这个文件里没有用到任何一行 ESP32 专用的硬件代码，全部是最标准的 C++ 语法。
// 这样做有一个超级大的好处：我们可以直接用电脑（运行 tests/test_posture.cpp）给这个“大脑”
// 喂假数据做“模拟考试”，1 秒钟就能检查所有数学公式对不对，不用每次都烧录到板子上试！
//
// 数据在这个文件里会依次闯过【五道关卡】：
//   第 1 关：decodeFrame() —— 拆开 54 字节的无线快递包，取出设备号和 X/Y/Z 三个角度
//   第 2 关：Pairer        —— 把几乎同时到达（相差 ≤ 12毫秒）的大腿角和小腿角配成一对
//   第 3 关：kneeFlexion() —— 用“小腿角 - 大腿角 - 站直零偏”算出膝盖到底弯了多少度
//   第 4 关：WaistWindow   —— 收集腰部最近 1 秒的数据，像体操裁判一样去掉最高最低刺点，算晃动幅度
//   第 5 关：Hold          —— 拿着秒表的铁面裁判，越界动作连续保持够久（0.8秒或0.5秒）才吹哨报警
// ============================================================================

// #pragma once 的意思是：不管别的文件包含了我多少次，编译时只读我一次，防止重复定义报错。
#pragma once

// 引入 C++ 标准工具箱（头文件）：
#include <algorithm> // 提供 std::sort（从小到大排队排序）和 std::max（两个数里挑大的）
#include <cmath>     // 提供 std::fmod（小数取余数，就像整数里的 % 号）
#include <cstddef>   // 提供 size_t（专门用来表示“第几个下标”或“总共有多少个”的非负整数类型）
#include <cstdint>   // 提供 uint32_t（32位无符号整数，专门存毫秒时间）和 uint8_t（0~255 的单字节）
#include <cstring>   // 提供 std::memcpy（按字节把一段内存直接复印到另一段内存）

// namespace ski 叫“命名空间”：相当于给下面所有的变量和函数贴上“ski::”的姓氏标签，
// 防止跟别的库里碰巧同名的函数撞车（在外面调用时要写 ski::wrap180、ski::Pairer 等）。
namespace ski {

// ============================================================================
// 第一部分：全局常数设置（的时间单位都是毫秒 ms，1 秒 = 1000 毫秒）
// constexpr 表示这些数字在程序编译时就固定死了，运行中绝不会被意外改掉。
// ============================================================================

// PairMs = 12 毫秒：大腿(T)和小腿(S)两帧数据的“最大允许到站时间差”。
// 传感器每秒发 50 次数据（也就是每 20 毫秒发 1 次）。
// 只有当大腿和小腿的数据到达 ESP32 的时间差不超过 12 毫秒时，我们才认为它们拍下的是“同一瞬间的腿”。
constexpr uint32_t PairMs = 12;

// GapMs = 100 毫秒：判断传感器“掉线/断流”的时间门槛。
// 正常每 20 毫秒就该来一帧数据。如果超过 100 毫秒（相当于连续丢了 5 帧）还没动静，
// 就说明这枚传感器可能断电或信号断了，必须立刻清空旧的秒表和窗口，不能拿老黄历继续算！
constexpr uint32_t GapMs = 100;

// WindowMs = 1000 毫秒（1 秒）：腰部(W)观察骨盆晃动的“时间放大镜窗口长度”。
// 程序永远只看“最近 1 秒钟之内”腰部晃了多少度。
constexpr uint32_t WindowMs = 1000;

// 下面三个是课堂演示用的【动作报警阈值】（单位：度 °，末尾的 f 表示它是单精度小数 float）：
// （注：真正去滑雪场测试时，这三个数要根据教练标出的个人正常滑行数据重新调整）
constexpr float KneeLow = 20.0f;   // 膝角下限 20°：如果膝盖弯曲小于 20°，说明腿站得太直了（僵硬，容易后坐摔倒）
constexpr float KneeHigh = 45.0f;  // 膝角上限 45°：如果膝盖弯曲大于 45°，说明蹲得太深了（大腿很快会酸痛没力气）
constexpr float WaistHigh = 10.0f; // 腰部波动上限 10°：如果最近 1 秒腰部来回晃动超过 10°，说明上半身不稳在乱晃

// ============================================================================
// 第二部分：【第 3 关工具】角度圆盘折返魔法与膝盖弯曲角公式
// ============================================================================

// 函数：wrap180 —— 把任意角度折回到 [-180°, 180°) 的范围里。
//
// 【为什么要写这个函数？（圆盘钟表难题）】
// 传感器输出的角度范围是 -180° 到 +180°。就像一个圆盘，+180° 和 -180° 其实是紧挨在一起的同一条分界线！
// 假如你的大腿传感器刚好指在 +179°，小腿传感器只稍微转了 2°，跨过了分界线变成了 -179°。
// 这时候如果直接用小腿减大腿：-179° - 179° = -358°！
// 程序会吓一跳：“天哪，你的腿转了整整一圈（358度）骨折了！”——其实它只转了 +2°！
// wrap180 的作用，就是把超出 [-180°, 180°) 的度数，通过加减 360° 折回真实的最小夹角。
inline float wrap180(float angle) {
    // 第一步：先加上 180°，把正常范围 [-180, 180) 平移成正数范围 [0, 360)；
    //         然后用 std::fmod(..., 360.0f) 除以 360° 取余数（不管转了多少个整圈 360° 都直接抹掉）。
    float x = std::fmod(angle + 180.0f, 360.0f);

    // 第二步：C++ 里的 fmod 有个脾气——如果被除数是负数，算出的余数也是负数（比如 -358 + 180 = -178）。
    //         所以如果余数 x 小于 0，我们就给它加上一圈 360°，把它拉回 [0, 360) 的正数区间（-178 + 360 = +182）。
    if (x < 0) x += 360.0f;

    // 第三步：刚才第一步借了 180°，现在减去 180° 还回去！结果就稳稳落在 [-180°, 180°) 之间了（182 - 180 = +2°）。
    return x - 180.0f;
}

// 函数：kneeFlexion —— 计算校准后的膝关节弯曲角 K（单位：度）。
//
// 【参数说明】
//   • thigh        ：当前大腿传感器(T)的角度
//   • shank        ：当前小腿传感器(S)的角度
//   • standingDiff ：刚开始站得笔直校准（发 CAL 命令）时，记下的“小腿角 - 大腿角”天生安装差值（零偏）
//
// 【数学原理（两把尺子量铰链）】
// 为什么不直接用“小腿角 - 大腿角”，还要再减一个 standingDiff 呢？
// 因为人的腿有肉、绑带也会绑歪。也许你站得像军人一样笔直（膝盖弯曲 0°）时，
// 小腿读数是 +2°，大腿读数是 -4°，它们天生就差了 2° - (-4°) = 6°（这就是 standingDiff = 6°）。
// 当你屈膝蹲下时，假如小腿变成 +12°，大腿变成 -8°：
//   现在的角差 = 12° - (-8°) = 20°；
//   扣掉天生的歪斜 6° = 20° - 6° = 14°！这 14° 才是你膝盖真正弯曲的度数！
// 最后套一层 wrap180(...)，就算传感器绑在 ±180° 分界线附近也绝不会算错。
inline float kneeFlexion(float thigh, float shank, float standingDiff) {
    return wrap180(shank - thigh - standingDiff);
}

// ============================================================================
// 第三部分：【第 1 关】拆开 54 字节的无线快递包裹（decodeFrame）
// ============================================================================

// Frame（数据帧结构体）：就像一张“快递提取单”。
// 一包 54 字节的原始数据里有很多我们本课用不着的东西（比如加速度、角速度、磁场、内部时钟），
// 拆包后，我们只把本课最需要的两样东西填进这张单子里：
struct Frame {
    char id[13];    // 传感器的 12 位身份证号（比如 "WT5500014327"）。
                    // 为什么数组大小是 13 而不是 12？因为 C/C++ 的字符串规矩是：最后第 13 个格子必须放 '\0'（结束符）！
    float angle[3]; // 传感器算好的三个方向倾角（单位：度）：
                    // angle[0] 是 X 轴角，angle[1] 是 Y 轴角，angle[2] 是 Z 轴角。
};

// 函数：decodeFrame —— 检查并拆解一包 54 字节的 WT901PWIFI 传感器数据。
//
// 【参数说明】
//   • data  ：指向收到的那串原始字节数组的开头（uint8_t 就是 0~255 的单个字节）
//   • size  ：这串字节一共有多少个
//   • frame ：拆出来的设备号和三个角度，会直接填进这个 frame 单子里（注意 & 表示直接修改外面的 frame）
// 【返回值】
//   • 如果包裹完整合法，拆包成功，返回 true；如果包裹破损或格式不对，立刻拒收返回 false。
inline bool decodeFrame(const uint8_t *data, size_t size, Frame &frame) {
    // -------------------- 安检第 1 步：查长度、查头、查尾 --------------------
    // 1) size < 54：包裹连 54 个字节都不够，肯定半路丢东西了，拒收！
    // 2) data[0] != 'W' || data[1] != 'T'：维特传感器的包裹开头前两个字节必须是大写字母 'W' 和 'T'！
    // 3) data[52] != 0x0D || data[53] != 0x0A：包裹最后两个字节（第52、53号下标）必须是回车(0x0D)和换行(0x0A)！
    if (size < 54 || data[0] != 'W' || data[1] != 'T' ||
        data[52] != 0x0D || data[53] != 0x0A) return false;

    // -------------------- 安检第 2 步：查身份证号是不是纯数字 --------------------
    // 下标 0 和 1 是 'W' 'T'，紧接着下标 2 到 11（一共 10 个字节）必须全都是 '0' 到 '9' 的数字字符。
    // 如果里面混进了乱码符号，说明包裹在无线传输时被干扰坏了，拒收！
    for (size_t i = 2; i < 12; ++i) {
        if (data[i] < '0' || data[i] > '9') return false;
    }

    // -------------------- 拆包第 1 步：复印 12 位设备编号 --------------------
    // 把开头 12 个字节（比如 "WT5500014327"）原封不动复印到 frame.id 里，并在第 12 号下标补上结束符 '\0'。
    std::memcpy(frame.id, data, 12);
    frame.id[12] = '\0';

    // -------------------- 拆包第 2 步：拼积木算出 X / Y / Z 三个角度 --------------------
    // 在 54 字节说明书里，三个角度藏在靠后的位置，每个角度占 2 个字节：
    //   • X 轴角度（axis = 0）：藏在第 38、39 字节
    //   • Y 轴角度（axis = 1）：藏在第 40、41 字节
    //   • Z 轴角度（axis = 2）：藏在第 42、43 字节
    for (size_t axis = 0; axis < 3; ++axis) {
        // 算出当前轴从第几个字节开始：38 + 2*0 = 38；38 + 2*1 = 40；38 + 2*2 = 42
        const size_t offset = 38 + 2 * axis;

        // 【小端序拼积木】：为什么一个角度要用 2 个字节？因为 1 个字节最大才 255，装不下精确度数；
        // 两个字节拼起来可以表示 0 ~ 65535（256 × 256 - 1）。
        // 传感器发数据时遵守“小端序（Little-Endian）”规矩：低位字节在前，高位字节（256倍位）在后。
        // 就像十进制里“个位在前、十位在后”一样，拼起来就是：低字节 + 256 × 高字节。
        const int value = data[offset] + 256 * data[offset + 1];

        // 【还原正负号（补码原理）】：拼出来的 value 是 0 ~ 65535，那负数角度藏在哪儿呢？
        // 计算机把 65536 对半分开：
        //   • 前半圈（0 ~ 32767）代表正数（0° ~ +180°）；
        //   • 后半圈（32768 ~ 65535）代表负数！只要发现 value >= 32768，就给它减去一整圈 65536，就变回负数了！
        const int signedValue = value >= 32768 ? value - 65536 : value;

        // 【按比例尺换算成真正的度数】：
        // 厂家规定数字 32768 对应满量程 180.0 度。
        // 比如刚才拼出 signedValue = 16384（刚好是 32768 的一半），乘上 (180.0f / 32768.0f) 就得出 90.0 度！
        frame.angle[axis] = signedValue * (180.0f / 32768.0f);
    }
    return true; // 全部拆包完毕，返回成功！
}

// ============================================================================
// 第四部分：【第 5 关】铁面无私的“防误报裁判秒表”（Hold 结构体）
// ============================================================================

// Hold（持续越界计时器）：每一条报警规则（腿太直、蹲太深、腰乱晃）都配一只自己专属的 Hold 秒表。
//
// 【为什么不能一越界就立刻报警？】
// 滑雪场地上有小雪包和冰碴，滑行时膝盖哪怕有 0.1 秒稍微弹直了一点点也是完全正常的。
// 如果一越界就报警，提示音就会像机关枪一样响个不停。
// 所以裁判规定：错误的姿势必须【连续不中断】保持满规定时间（比如膝角 800 毫秒、腰部 500 毫秒），才吹一次哨！
struct Hold {
    bool active = false;  // 秒表现在是不是正在走字？（true = 正在越界计时中；false = 秒表停着）
    bool emitted = false; // 这一段连续越界是不是已经吹过哨、报过警了？（防止一直蹲着时每秒刷屏报几十次警）
    uint32_t since = 0;   // 按下秒表开始计时的那个起点时刻（单位：毫秒）

    // 函数：reset —— 把秒表彻底清零（回到初始状态：停表、未报警、起点归零）。
    void reset() { *this = Hold{}; }

    // 函数：update —— 每收到一次新的角度或波动值，就让裁判看一眼秒表。
    //
    // 【参数说明】
    //   • now     ：现在的毫秒时间（比如 900 ms）
    //   • outside ：现在的姿势是不是违规越界了？（true = 越界了；false = 姿势正常）
    //   • holdMs  ：规定必须连续保持多少毫秒才算犯规？（膝角传 800，腰部传 500）
    // 【返回值】
    //   • 只有在“刚刚好坚持满 holdMs 毫秒、触发报警的那一瞬间”返回 true！其他任何时候都返回 false。
    bool update(uint32_t now, bool outside, uint32_t holdMs) {
        // 情况 1：现在的姿势在正常范围内（!outside，没有越界）
        // 哪怕你刚才已经连续越界坚持了 799 毫秒（差 1 毫秒就报警了），只要这一帧回到了正常范围，
        // 秒表立刻无情清零（reset）！下次再越界必须重新从 0 毫秒开始攒！
        if (!outside) {
            reset();
            return false;
        }

        // 走到这里，说明当前一定越界了（outside == true）。
        // 情况 2：如果秒表还没按下去（!active），说明这是本次越界的“第 1 帧”！
        // 赶紧按下秒表（active = true），并拿小本本记下是从哪一毫秒开始的（since = now）。
        if (!active) {
            active = true;
            since = now;
        }

        // 情况 3：秒表已经在走字了。我们算一算从起点 since 到现在 now 一共坚持了多少毫秒（now - since）。
        // 如果这一段越界还没报过警（!emitted），而且坚持的时间已经达到或超过了规定的 holdMs（>= holdMs）：
        //   1) 把 emitted 锁死为 true（表示这次持续犯规已经罚过了，只要你不恢复正常，后面继续越界也不再重复吹哨）；
        //   2) 返回 true，告诉主程序：“快打印一条 E 报警事件！”
        // （小知识：因为 now 和 since 都是无符号整数 uint32_t，就算板子连开 49.7 天计时器溢出回绕到 0，now - since 依然算得准！）
        if (!emitted && now - since >= holdMs) {
            emitted = true;
            return true;
        }

        // 情况 4：虽然越界了，但要么还没坚持够时间（比如才过 300ms），要么这一段已经报过一次警了（emitted == true），
        // 所以继续保持沉默，返回 false。
        return false;
    }
};

// ============================================================================
// 第五部分：【第 2 关】大腿(T)与小腿(S)的“12 毫秒相亲配对室”（Pairer 结构体）
// ============================================================================

// Pairer（双腿实时配对器）：
//
// 【为什么算膝盖角度前必须先经过配对室？】
// 大腿传感器(T)和小腿传感器(S)是两块独立的无线模块，它们各自通过 Wi-Fi 发数据包，到达 ESP32 有先有后。
// 如果大腿在 100 毫秒发来一个角度，小腿因为网络卡了一下，在 500 毫秒才发来一个角度，
// 这两个角度差了 0.4 秒！拿 0.4 秒前的大腿和现在的小腿去算膝角，算出来完全是假的！
//
// 所以我们在配对室里摆了【两把等候椅】（下标 0 给大腿 T 坐，下标 1 给小腿 S 坐）：
struct Pairer {
    float angle[2] = {};   // 两把椅子上记录的角度：angle[0] 存大腿角，angle[1] 存小腿角
    uint32_t time[2] = {}; // 两把椅子上记录的到达时间：time[0] 是大腿到达毫秒，time[1] 是小腿到达毫秒
    bool pending[2] = {};  // 椅子上现在坐着人吗？（pending[0]=true 表示有一帧大腿数据正在等小腿；false 表示椅子空着）

    // 函数：reset —— 把两把等候椅同时清空（人走茶凉，谁也没在等）。
    void reset() { pending[0] = pending[1] = false; }

    // 函数：push —— 每当大腿(leg = 0)或小腿(leg = 1)来了一帧新数据，就送进配对室尝试配对。
    //
    // 【参数说明】
    //   • leg   ：谁来了？（0 代表大腿 T，1 代表小腿 S）
    //   • now   ：这帧数据到达 ESP32 的时刻（毫秒）
    //   • value ：这帧数据选好轴、乘好正负号之后的角度值
    //   • delta ：输出参数（带 & 号）——如果配对成功，顺便把两人相差了几毫秒填进 delta 带出去
    // 【返回值】
    //   • true  = 配对成功！外面的程序可以立刻拿 angle[0] 和 angle[1] 去算膝角 K 了！
    //   • false = 还没法配对（对面没人，或者对面那个人等太久过期了），继续等下一帧。
    bool push(size_t leg, uint32_t now, float value, uint32_t &delta) {
        // 巧妙的小算术：如果来的 leg 是 0（大腿），那么对面椅子 other = 1 - 0 = 1（小腿）；
        //              如果来的 leg 是 1（小腿），那么对面椅子 other = 1 - 1 = 0（大腿）！
        const size_t other = 1 - leg;

        // 第 1 步：不管三七二十一，刚来的这个新数据先坐进自己的椅子里（如果自己椅子上本来有旧数据，直接被新来的覆盖）。
        angle[leg] = value;
        time[leg] = now;
        pending[leg] = true; // 标记：我的椅子上有人了！

        // 第 2 步：抬头看一眼对面的椅子（other）上坐着人吗？
        // 如果对面椅子是空的（!pending[other]），巴掌拍不响，只能返回 false 老老实实坐着等对面来人。
        if (!pending[other]) return false;

        // 第 3 步：对面椅子上居然有人在等我！赶紧算一算：我到达的时间（now）比对面到达的时间（time[other]）晚了多少毫秒？
        delta = now - time[other];

        // 第 4 步：检查时差合不合格！
        // 如果时差 delta 超过了 12 毫秒（PairMs），说明对面椅子上坐着的那条数据太老了（过期作废）！
        // 于是把对面椅子清空（pending[other] = false），但注意：我自己（pending[leg]）是刚刚才到的新鲜数据，
        // 所以我继续留在椅子上等对面的下一帧！本次配对失败，返回 false。
        if (delta > PairMs) {
            pending[other] = false;
            return false;
        }

        // 第 5 步：太棒了！时差 delta <= 12 毫秒，两人几乎是同一瞬间到达的！
        // 牵手配对成功！立刻调用 reset() 把两把椅子的 pending 都设成 false（防止同一帧数据被下一帧重复配对第二次）。
        // （注意：reset 只把 pending 开关关掉，刚才存进 angle[0] 和 angle[1] 的角度还在，外面马上就能读出来算膝角！）
        reset();
        return true;
    }
};

// ============================================================================
// 第六部分：【第 4 关】腰部(W) 1 秒晃动放大镜与“体操裁判打分法”（percentile 与 WaistWindow）
// ============================================================================

// 函数：percentile —— 在一排已经【从小到大排好队】的数字里，找出排在某个百分比位置（比如前 10% 或前 90%）的数。
//
// 【参数说明】
//   • sorted   ：已经按从小到大排好序的角度数组（第 0 个最小，第 count-1 个最大）
//   • count    ：数组里一共有多少个数字
//   • fraction ：你要找百分之几的位置？（传 0.1f 就是找第 10% 的低位 P10；传 0.9f 就是找第 90% 的高位 P90）
//
// 【如果位置刚好落在两个数字中间怎么办？（线性插值）】
// 比如一共有 5 个数（下标 0, 1, 2, 3, 4），你要找 50%（0.5）的位置：(5-1) × 0.5 = 2.0，刚好是第 2 号下标。
// 但如果你找的位置算出来是下标 2.3（落在第 2 号和第 3 号之间，离 2 号距离 0.3）：
// 那就用：第2号的值 + 0.3 × (第3号的值 - 第2号的值)。就像在尺子两个刻度中间按比例估读一样精确！
inline float percentile(const float *sorted, size_t count, float fraction) {
    const float index = (count - 1) * fraction;      // 算出理想的小数下标位置
    const size_t lower = static_cast<size_t>(index); // 去掉小数点后面，得到左边相邻的整数下标
    if (lower + 1 == count) return sorted[lower];    // 如果刚好落在队尾最后一个数上，直接返回它
    // 落在 lower 和 lower+1 两个格子之间时，按小数距离 (index - lower) 做比例插值：
    return sorted[lower] + (index - lower) * (sorted[lower + 1] - sorted[lower]);
}

// 类：WaistWindow（腰部 1 秒滑动窗口）
//
// 【单板滑雪时，怎样用数学判断“腰部/骨盆是不是在乱晃”？】
// 滑行时，人的上身本来就需要保持一定的倾角（比如一直保持前倾 15° 不动，这是好姿势，不能报警！）。
// 真正糟糕的姿势是：在 1 秒钟之内，腰一会儿前倾、一会儿后仰，或者左右来回摇摆！
// 所以我们要看的是：【最近 1 秒钟之内，腰部角度来回变化的宽度（最大到最小的跨度）有多大】。
//
// 【为什么不用“最大值 - 最小值”，而要用“P90（前90%） - P10（前10%）”？】
// 想象体操比赛打分：为什么要“去掉一个最高分，去掉一个最低分”？
// 因为滑雪时雪板一旦压到一颗小冰粒，腰部传感器可能会有 1 帧数据因为剧烈震动突然跳到 140°（刺点噪声）。
// 如果用“最大值 - 最小值”，这 1 帧刺点就会骗过电脑，算出晃了 140° 而误报警！
// 而我们把 1 秒内的约 50 个数据从小到大排成一排，砍掉最头的 10% 和最尾的 10%，
// 用排在 90% 位置的数（P90）减去排在 10% 位置的数（P10），那 1~2 帧偶发的震动刺点就被完美扔掉了！
class WaistWindow {
public:
    // 函数：clear —— 清空整个滑动窗口（从 0 开始重新收集数据）。
    void clear() { head = count = 0; }

    // 函数：push —— 每收到一帧腰部传感器(W)的数据，就塞进这个 1 秒滑动窗口里，并尝试算出当前的晃动幅度 wave。
    //
    // 【参数说明】
    //   • now   ：这帧腰部数据到达的时刻（毫秒）
    //   • pitch ：当前腰部的前后俯仰角（度）
    //   • roll  ：当前腰部的左右侧倾角（度）
    //   • wave  ：输出参数（带 & 号）——如果窗口攒够了 1 秒，算出的晃动幅度 W 会填进这里带出去
    // 【返回值】
    //   • true  = 窗口已经攒满整整 1 秒、且有效数据够 35 个，成功算出了波动 W！
    //   • false = 刚启动还不到 1 秒，或者中途掉线/丢包太多，暂时不能算波动 W。
    bool push(uint32_t now, float pitch, float roll, float &wave) {
        // 第 1 步（查断流）：如果队列里已经有数据（count > 0），但现在的时间 now 比上一帧（at(count - 1).time）
        // 晚了超过 100 毫秒（GapMs），说明腰部传感器刚才断线过！以前的老数据不能要了，立刻 clear() 清空重来。
        if (count && now - at(count - 1).time > GapMs) clear();

        // 第 2 步（踢走 1 秒前的老数据）：
        // 只要队列里第 2 老的样本（at(1)）距离现在都已经达到或超过 1000 毫秒（WindowMs）了，
        // 就调用 pop() 把最老的第 1 个样本（at(0)）踢出队列。
        // （为什么要看 at(1) 而不是 at(0)？因为我们故意留 1 条刚好在 1 秒边界上或边界外一点点的老样本 at(0) 作证人，
        //   用来在下面第 5 步证明：“我们的窗口确实已经跨满整整 1000 毫秒了！”）
        while (count > 1 && now - at(1).time >= WindowMs) pop();

        // 第 3 步（防撑爆保护）：我们的环形队列总共准备了 128 个座位（Capacity = 128）。
        // 正常每秒 50 帧只占约 51 个座位；万一塞满了 128 个，就先把最老的踢掉一个腾出座位。
        if (count == Capacity) pop();

        // 第 4 步（新数据入座）：把当前这一帧的 {时间, 前后倾, 左右倾} 存进环形队列的队尾，总人数 count 加 1。
        samples[(head + count) % Capacity] = {now, pitch, roll};
        ++count;

        // 第 5 步（检查有没有攒满 1 秒）：
        // 看看队头最老的那条“证人样本” at(0)，距离现在满 1000 毫秒（WindowMs）了吗？
        // 如果还不到 1000 毫秒（比如刚按下 START 才过了 0.5 秒），时间不够长，先返回 false 不算波动。
        if (now - at(0).time < WindowMs) return false;

        // 第 6 步（挑出真正落在最近 1 秒内的样本）：
        // 如果队头那条“证人样本” at(0) 距离现在已经超过 1000 毫秒了（> WindowMs），那它只是用来证明时间跨度的，
        // 真正参与统计要从下标 1 开始（first = 1）；如果 at(0) 刚好等于 1000 毫秒，就从下标 0 开始（first = 0）。
        const size_t first = now - at(0).time > WindowMs ? 1 : 0;
        const size_t used = count - first; // used 就是最近 1.0 秒内真正有效的数据个数！

        // 第 7 步（检查数据够不够密）：
        // 传感器正常工作在 50Hz 时，1 秒钟应该收到 50 个左右的数据。
        // 如果 1 秒内收到的数据连 35 个都不到（used < 35），说明无线信号丢包太严重，或者传感器没设成 50Hz！
        // 用太稀疏的数据算波动不靠谱，直接返回 false 拒绝计算。
        if (used < 35) return false;

        // 第 8 步（复印到草稿纸并解决 ±180° 跨界难题）：
        // 把这 used 个有效样本从原队列复制到两张“排序草稿纸”（pitchWork 和 rollWork）上。
        // 复制的时候，顺便让每个历史角度减去当前最新一帧的角度（sample.pitch - pitch），再套上 wrap180！
        // 【这样做一举两得】：
        //   1) 所有数同时减去同一个常数，排好序后算“第90名 - 第10名”的差值完全不变！
        //   2) 如果腰部刚好在 +179° 和 -179° 分界线附近晃了 2°，直接排序会把 -179° 排第一、+179° 排最后，误算成晃了 358°！
        //      而减去最新读数再用 wrap180 展开后，它们都会变成 0° 附近的 ±2°，彻底消灭了跨界误报！
        for (size_t i = 0; i < used; ++i) {
            const auto &sample = at(first + i);
            pitchWork[i] = wrap180(sample.pitch - pitch);
            rollWork[i] = wrap180(sample.roll - roll);
        }

        // 第 9 步（在草稿纸上从小到大排队）：
        // 注意：绝对不能直接拿原队列 samples 去排序！因为原队列必须保持“按时间先后排队”，下一帧才知道谁最老该淘汰。
        // 所以我们只对两张草稿纸数组 pitchWork 和 rollWork 调用 std::sort 从小到大排序。
        std::sort(pitchWork, pitchWork + used);
        std::sort(rollWork, rollWork + used);

        // 第 10 步（体操裁判算分：P90 - P10）：
        // 分别算出前后倾（pitchSpan）和左右倾（rollSpan）的 P90 - P10 晃动宽度，
        // 然后用 std::max 挑出晃得更厉害的那个方向，作为最终的腰部波动幅度 wave（也就是串口打印的 W）！
        const float pitchSpan = percentile(pitchWork, used, 0.9f) -
                                percentile(pitchWork, used, 0.1f);
        const float rollSpan = percentile(rollWork, used, 0.9f) -
                               percentile(rollWork, used, 0.1f);
        wave = std::max(pitchSpan, rollSpan);
        return true; // 计算成功！
    }

private:
    // -------------------- 内部存储结构：巧妙的“环形数组（旋转寿司传送带）” --------------------
    // 为什么不用普通数组从 0 排到 count-1？
    // 因为如果用普通数组，每次踢掉队头第 0 个老数据时，后面 50 个数据都要全部往前搬一格座位，太浪费时间了！
    // 用“环形数组”就像一个有 128 个盘子的旋转寿司圆桌：
    //   • 我们只用 head 记住“当前最老的第 1 盘坐在几号位”，用 count 记住“桌上现在一共有几盘”。
    //   • 踢掉最老的一盘（pop）时，一盘都不用搬，只要把 head 往后指一格（(head + 1) % 128），总数 count 减 1 就行了！
    //   • 往队尾放新一盘时，直接放到 (head + count) % 128 的位置（走到 127 号末尾后，% 128 会自动绕回 0 号开头）！
    enum { Capacity = 128 };
    struct Sample { uint32_t time; float pitch; float roll; };
    Sample samples[Capacity] = {};  // 存放最近 1 秒腰部数据的环形圆桌队列
    float pitchWork[Capacity] = {}; // 专门用来给前后倾排序的“草稿纸数组”
    float rollWork[Capacity] = {};  // 专门用来给左右倾排序的“草稿纸数组”
    size_t head = 0;                // 队头指针：当前最老的那条数据在 samples 数组的几号下标
    size_t count = 0;               // 队列里当前一共存了多少条数据

    // 辅助小函数 at(index)：给你逻辑上的“第 index 老”的数据（0 是最老，count-1 是最新），自动算出它在圆桌上的真实下标。
    const Sample &at(size_t index) const { return samples[(head + index) % Capacity]; }

    // 辅助小函数 pop()：把队头最老的一条数据踢走（队头指针往后挪一步，总个数减 1）。
    void pop() {
        head = (head + 1) % Capacity;
        --count;
    }
};

}  // namespace ski
